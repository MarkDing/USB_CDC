# Keil uVision project sim3u1xx_usb_cdc.uvproj, settings and files
target sim3u1xx_usb_cdc (ARM-ADS)
  device: SiM3U167 Silicon Laboratories, Inc.
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: CMPApp
  c flags: Optim=1
  c define: NDEBUG
  c misc: --c99 --gnu
  c include: .\src\;.\src\generated;.\src\VirtualSerial;C:\Silabs\32bit\si32-1.1.1\si32Hal\sim3u1xx;C:\Silabs\32bit\si32-1.1.1\si32Hal\CPU;C:\Silabs\32bit\si32-1.1.1\si32Hal\SI32_Modules
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: C:\Silabs\32bit\si32-1.1.1\si32Hal\sim3u1xx\linker_sim3u1xx_arm.sct
  group CPU
    C:/Silabs/32bit/si32-1.1.1/si32Hal/CPU/: retarget_arm.c
  group SI32_Modules
    C:/Silabs/32bit/si32-1.1.1/si32Hal/SI32_Modules/: SI32_USB_A_Type.c SI32_USBEP_A_Type.c SI32_WDTIMER_A_Type.c
  group sim3u1xx
    C:/Silabs/32bit/si32-1.1.1/si32Hal/sim3u1xx/: startup_sim3u1xx_arm.s system_sim3u1xx.c
  group generated
    ./src/generated/: gCLKCTRL.c gCpu.c gFLASHCTRL0.c gModes.c gPB.c gUART0.c gUSB0.c
  group VirtualSerial
    ./src/VirtualSerial/: Descriptors.c VirtualSerial.c
    ./src/: main.c
  group LUFA
    ./src/LUFA/Drivers/USB/Class/Device/: CDCClassDevice.c
    ./src/LUFA/Drivers/USB/Core/: DeviceStandardReq.c USBTask.c
    ./src/LUFA/Drivers/USB/Core/SIM3U/: Device_SIM3U.c Endpoint_SIM3U.c EndpointStream_SIM3U.c USBController_SIM3U.c USBInterrupt_SIM3U.c
